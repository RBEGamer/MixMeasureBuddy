# Autodesk Inventor part: bottom
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2023-07
Part Number: bottom
Material: Generic
Document SubType Name: Modeling
Designer: AdminForWorker
Density: 1 g/cm^3
Appearance: Default
Title: bottom
Author: AdminForWorker
## Design history (mm, degrees)
feature "bottom"
body "Solid1"
